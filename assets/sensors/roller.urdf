Commit message: add cylinder gelsight support

File: assets/sensors/roller.urdf (robot description, URDF)
Before this commit: robot digit, 1 links, 0 joints
Links:
- link baseLink: geometry collision cylinder length=0.03 radius=0.015; visual cylinder length=0.03 radius=0.015
